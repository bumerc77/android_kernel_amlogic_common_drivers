## Kconfig.ext
```kconfig
# SPDX-License-Identifier: GPL-2.0

source "$(KCONFIG_EXT_PREFIX)drivers/Kconfig"
source "$(KCONFIG_EXT_PREFIX)sound/Kconfig"
```
